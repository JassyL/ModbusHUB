# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ModbusHUB +hex
  AfterMake: fromelf --bin !L --output ModbusHUB.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, RT_USING_ARM_LIBC
  c include: .;rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;packages\EasyFlash-v4.1.0\inc;packages\fal-v0.5.0\inc;packages\libmodbus-latest\examples;packages\libmodbus-latest\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\termios;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c fal_flash_stm32f4_port.c init.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_qspi.c drv_wdt.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group EasyFlash
    packages/EasyFlash-v4.1.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    packages/EasyFlash-v4.1.0/ports/: ef_fal_port.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c
  group libmodbus
    packages/libmodbus-latest/examples/: modbus_rtu_test.c
    packages/libmodbus-latest/src/: modbus.c modbus-data.c modbus-rtu.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
    rt-thread/components/libc/termios/: posix_termios.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
